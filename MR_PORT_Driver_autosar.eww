<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MR_PORT_AUTOSAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


